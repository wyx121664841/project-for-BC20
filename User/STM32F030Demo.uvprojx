# Keil uVision project STM32F030Demo.uvprojx, settings and files
target Stm32f030demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030CCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030Demo
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F030XC
  c include: ..\CORE;..\HARDWARE;..\STM32F03x_FWLib\inc;..\STM32F03x_FWLib\src;..\User;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c stm32f0xx_it.c
  group CORE
    ./: system_stm32f0xx.c
    ../CORE/: startup_stm32f030xc.s
  group HARDWARE
    ../HARDWARE/: USART1.c
  group SYSTEM
    ../SYSTEM/: delay.c
  group STM32F03x_FWLib
    ../STM32F03x_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_pwr.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_wwdg.c
target DQHZAPP (ARM-ADS)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EC200S
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\OBJ\EC200S.bin  ..\OBJ\EC200S.axf
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX  APP
  c include: as above
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xc0
  memory RVCT10: RAM 0x200000c0 size 0x1f40
